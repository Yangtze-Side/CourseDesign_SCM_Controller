# Keil uVision project Controller_bk1.uvproj, settings and files
target Controller (MCS-51)
  device: STC15W4K32S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000)
  output: Controller +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Sources\inc;.\Communication;.\User;.\User_Lib;.\User_Driver;.\IMU;.\Key;.\Display;.\Display\OLED;.\Display\Pages;.\Joystick;.\Control;.\Encoder;.\FOC;.\FOC\Math
  group Communication
    ./Communication/: communication.c communication.h contract.h
  group IMU
    ./IMU/: imu_app.c imu_app.h imu_def.c imu_def.h imu_solution_quat.c imu_solution_quat.h MPU6500_SPI.c MPU6500_SPI.h
  group User
    ./User/: system.c system.h task.c task.h
  group User_Lib
    ./User_Lib/: user_def.h user_lib.h user_math.c user_math.h user_fifo.c user_fifo.h
  group User_Driver
    ./User_Driver/: user_driver.h user_pwm.c user_pwm.h user_soft_iic.c user_soft_iic.h user_spi.c user_spi.h user_uart_fifo.c user_uart_fifo.h
  group Key
    ./Key/: key_SL.c key_SL.h key_ud.c key_ud.h
  group Joystick
    ./Joystick/: Joystick.c Joystick.h
  group Display
    ./Display/: Display.c Display.h
  group Display/OLED
    ./Display/OLED/: Font_CN.c Font_CN.h Font_EN.c Font_EN.h OLED.c OLED.h
  group Display/Pages
    ./Display/Pages/: Page_Main.c Page_Main.h Pages.h Page_About.c Page_About.h Page_Control.c Page_Control.h Page_Example.c Page_Example.h Page_Music.c Page_Music.h Page_Settings.c Page_Settings.h Page_Settings_AFPID.c Page_Settings_AFPID.h Page_Settings_AR.c Page_Settings_AR.h PAGE_Settings_GPID.c PAGE_Settings_GPID.h
  group Control
    ./Control/: control.c control.h
  group Encoder
    ./Encoder/: AS5600.c Encoder_iic.c Encoder_iic.h AS5600.h EncoderKey.c EncoderKey.h
  group AiCube
    ./Sources/: main.c port.c timer.c uart.c exti.c adc.c spi.c
  group FOC
    ./FOC/: FOC.c FOC.h FOC_Util.c FOC_Util.h FOC_Simulation.c FOC_Simulation.h FOC_App.c FOC_App.h
  group FOC/Math
    ./FOC/Math/: FOC_Math.c FOC_Math.h PosPID.c PosPID.h
